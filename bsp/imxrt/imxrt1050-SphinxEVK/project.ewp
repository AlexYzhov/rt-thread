# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\components\dfs\filesystems\devfs; ..\..\..\components\finsh; ..\..\..\components\drivers\include; packages\micropython-latest; ..\..\..\components\libc\pthreads; ..\..\..\components\libc\compilers\dlib; ..\..\..\components\libc\compilers\common; ..\Libraries\imxrt1050\devices\MIMXRT1052\utilities; packages\CmBacktrace-v1.2.2; ..\..\..\components\dfs\filesystems\ramfs; ..\..\..\components\dfs\include; ..\Libraries\imxrt1050\devices\MIMXRT1052; drivers; packages\micropython-latest\port; .; xip; ..\..\..\components\drivers\spi; ..\Libraries\imxrt1050\CMSIS\Include; applications; ..\..\..\components\dfs\filesystems\elmfat; ..\..\..\include; ..\..\..\components\libc\time; ..\..\..\libcpu\arm\common; ..\Libraries\imxrt1050\devices\MIMXRT1052\drivers; ..\..\..\libcpu\arm\cortex-m7; ..\Libraries\imxrt1050\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\Libraries\imxrt1050\devices\MIMXRT1052\iar\MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkExtraOptions: --keep image_vector_table; --keep boot_data; --keep dcd_data; --keep xip_config
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: lcd_init.c main.c
  group cm_backtrace
    packages/CmBacktrace-v1.2.2/: cm_backtrace.c cmb_port.c
  group CORTEX-M7
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/cputime/: cputime.c cputime_cortexm.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
  group dlib
    ../../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    drivers/: board.c
    ../Libraries/imxrt1050/drivers/: drv_cache.c drv_i2c.c drv_pin.c drv_sdio.c drv_sdram.c drv_spi_bus.c drv_uart.c
  group Filesystem
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/ramfs/: dfs_ramfs.c
  group finsh
    ../../../components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/common/: gmtime_r.c
  group Libraries
    ../Libraries/imxrt1050/devices/MIMXRT1052/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
    ../Libraries/imxrt1050/devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../Libraries/imxrt1050/devices/MIMXRT1052/: system_MIMXRT1052.c
  group MicroPython
    packages/micropython-latest/port/: _frozen_mpy.c file.c gccollect.c help.c machine_hw_i2c.c machine_hw_spi.c machine_pin.c machine_uart.c modmachine.c modnetwork.c modpyb.c modrtthread.c moduos.c moduos_file.c modusocket.c modutime.c mphalport.c mpthreadport.c mpy_main.c rtt_getchar.c
    packages/micropython-latest/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnative.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpy_scheduler.c mpz.c nativeglue.c nlr.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c pystack.c qstr.c reader.c repl.c runtime.c runtime_utils.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    packages/micropython-latest/lib/utils/: interrupt_char.c printf.c pyexec.c
    packages/micropython-latest/extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modubinascii.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_reader.c virtpin.c
    packages/micropython-latest/lib/netutils/: netutils.c
    packages/micropython-latest/lib/mp-readline/: readline.c
    packages/micropython-latest/drivers/bus/: softqspi.c softspi.c
    packages/micropython-latest/lib/timeutils/: timeutils.c
  group pthreads
    ../../../components/libc/time/: clock_time.c posix_sleep.c
    ../../../components/libc/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
  group xip
    xip/: fsl_flexspi_nor_boot.c xip_config.c
